# Keil uVision project apollo2.uvprojx, settings and files
target apollo2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apollo2 +hex
  c flags: oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\sdk;.\sdk\apollo2;.\sdk\bsp;.\sdk\devices;.\sdk\utils;.\sdk\apollo2\hal;.\sdk\apollo2\regs
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  link misc: ./sdk/apollo2/hal/keil/bin/libam_hal.lib(am_hal_global.o) --keep=am_hal_global.o(.data)
  group src
    ./src/: main.c
  group utils
    ./sdk/utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
  group devices
    ./sdk/devices/: am_devices_led.c
  group lib
    ./sdk/bsp/keil/bin/: libam_bsp.lib
    ./sdk/apollo2/hal/keil/bin/: libam_hal.lib
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, Device:Startup 1.0.0
